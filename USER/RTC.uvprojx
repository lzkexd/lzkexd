# Keil uVision project RTC.uvprojx, settings and files
target RTC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\RTC;..\USMART;..\HARDWARE\OLED;..\HARDWARE\TIMER;..\HARDWARE\PCA9685
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PCA9685/: stm32_pca9685.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_rtc.c stm32f10x_tim.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
